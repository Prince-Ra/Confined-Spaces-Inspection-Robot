options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs2_rx
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: decoded.ts
    type: byte
  states: {}
- name: dvbs2rx_bbdeheader_bb_0
  id: dvbs2rx_bbdeheader_bb
  parameters:
    debug_level: '0'
    framesize: '''normal'''
    rate: '''9/10'''
    standard: '''DVB-S2'''
  states: {}
- name: dvbs2rx_bbdescrambler_bb_0
  id: dvbs2rx_bbdescrambler_bb
  parameters:
    framesize: '''normal'''
    rate: '''9/10'''
    standard: '''DVB-S2'''
  states: {}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    debug_level: '0'
    framesize: '''normal'''
    outputmode: OM_MESSAGE
    rate: '''9/10'''
    standard: '''DVB-S2'''
  states: {}
- name: dvbs2rx_rx_hier_0
  id: dvbs2rx_rx_hier
  parameters:
    agc_gain: '1'
    agc_rate: '1e-5'
    agc_ref: '1'
    debug: '0'
    frame_size: '''normal'''
    gold_code: '0'
    modcod: '''QPSK9/10'''
    pl_freq_est_period: '20'
    rolloff: '0.2'
    rrc_delay: '25'
    rrc_nfilts: '128'
    sps: '2'
    sym_rate: symbol_rate
    sym_sync_damping: '1.0'
    sym_sync_loop_bw: '0.0045'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: '''dvbs2rx'''
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 900e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    legend: 'False'
    name: '"PL Sync Output"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    legend: 'False'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Before
    label2: After
    name: '"Frequency Correction"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: I
    label2: Q
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: PLFRAME Symbols
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ldpc-bch
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ldpc-bch
  states: {}

connections:
- [dvbs2rx_bbdeheader_bb_0, '0', blocks_file_sink_0, '0']
- [dvbs2rx_bbdescrambler_bb_0, '0', dvbs2rx_bbdeheader_bb_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', dvbs2rx_bbdescrambler_bb_0, '0']
- [dvbs2rx_rx_hier_0, '0', virtual_sink_1, '0']
- [dvbs2rx_rx_hier_0, '1', qtgui_const_sink_x_1_0, '0']
- [dvbs2rx_rx_hier_0, '2', qtgui_const_sink_x_1, '0']
- [dvbs2rx_rx_hier_0, '2', qtgui_time_sink_x_1, '0']
- [dvbs2rx_rx_hier_0, '3', qtgui_freq_sink_x_0, '0']
- [dvbs2rx_rx_hier_0, '4', qtgui_freq_sink_x_0, '1']
- [osmosdr_source_0, '0', dvbs2rx_rx_hier_0, '0']
- [virtual_source_1, '0', dvbs2rx_bch_decoder_bb_0, '0']

metadata:
  file_format: 1
